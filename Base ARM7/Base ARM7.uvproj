# Keil uVision project Base ARM7.uvproj, settings and files
target DEV (ARM-ADS)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: DEV_TESTS
  c flags: Optim=1
  c include: ..\_Common\inc;C:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group main
    ./source/: main.c definitions.h game.c
    ../_Common/src/: Startup.s LPC2300.s
  group BoardPeripherals
    ./source/: dKeyboard.c dLCD.c dLED.c
  group Utils
    ./source/: sUtils.c fList.c
  group InternalPeripherals
    ./source/: uart.c irq.c rtc.c dPWM.c
target GAME (ARM-ADS)
  device: LPC2378 NXP
  cpu: as above
  output: GAME
  c flags: Optim=1
  c define: GENIUS_GAME
  c include: ..\_Common\inc;C:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
